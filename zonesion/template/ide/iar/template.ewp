# IAR project template.ewp, settings and files
configuration template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED; STM32F40_41xxx; _DLIB_FILE_DESCRIPTOR=1; USE_STDPERIPH_DRIVER; xWITH_IPV6; xWITH_II_802154; xWITH_RPL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\core; ..\..\..\..\core\net; ..\..\..\..\core\net\mac; ..\..\..\..\core\net\rpl; ..\..\..\..\core\net\rime; ..\..\..\common; ..\..\..\..\apps; ..\..\..\..\apps\shell; ..\..\..\..\apps\serial-shell; ..\..\..\..\cpu\arm\stm32f407\fwlib\inc; ..\..\..\..\cpu\arm\stm32f407\startup; ..\..\..\..\cpu\arm\stm32f407\cmsis\include; ..\..\..\..\cpu\arm\stm32f407; ..\..\dev; ..\..\app; ..\..\..\common\dev
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\cpu\arm\stm32f407\cmsis\Lib\ARM\arm_cortexM3l_math.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/serial-shell
    ../../../../apps/serial-shell/: serial-shell.c
  group app/shell
    ../../../../apps/shell/: shell.c
  group core/dev
    ../../../../core/dev/: leds.c nullradio.c
  group core/lib
    ../../../../core/lib/: assert.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c strncasecmp.c trickle-timer.c
  group core/net
    ../../../../core/net/: dhcpc.c hc.c nbr-table.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c rawpacket-udp.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    ../../../../core/net/mac/: contikimac.c csma.c cxmac.c frame802154.c framer-802154.c framer-nullmac.c lpp.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c sicslowmac.c xmac.c
  group core/net/rime
    ../../../../core/net/rime/: rimeaddr.c
  group core/net/rpl
    ../../../../core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    ../../../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile-aggregates.c profile.c rtimer.c stimer.c timer.c
  group cpu/arm/stm32f407
    ../../../../cpu/arm/stm32f407/: clock.c debug.c IIC3.c rtimer-arch.c spi1.c spi2.c spi3.c stm32f4xx_conf.h uart1.c uart2.c uart3.c uart4.c usart6.c watchdog.c
  group cpu/arm/stm32f407/cmsis/dsp/BasicMathFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f32.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_dot_prod_f32.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f32.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f32.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_offset_f32.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_scale_f32.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f32.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c
  group cpu/arm/stm32f407/cmsis/dsp/CommonTables
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
  group cpu/arm/stm32f407/cmsis/dsp/ComplexMathFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group cpu/arm/stm32f407/cmsis/dsp/ControllerFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group cpu/arm/stm32f407/cmsis/dsp/FastMathFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group cpu/arm/stm32f407/cmsis/dsp/FilteringFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q15.c arm_conv_opt_q7.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_partial_q7.c arm_conv_q15.c arm_conv_q31.c arm_conv_q7.c arm_correlate_f32.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q15.c arm_correlate_opt_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_q7.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_init_q7.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q15.c arm_fir_q31.c arm_fir_q7.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_init_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_fir_sparse_q7.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
  group cpu/arm/stm32f407/cmsis/dsp/MatrixFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
  group cpu/arm/stm32f407/cmsis/dsp/StatisticsFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f32.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f32.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_power_f32.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
  group cpu/arm/stm32f407/cmsis/dsp/SupportFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/SupportFunctions/: arm_copy_f32.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_fill_f32.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c
  group cpu/arm/stm32f407/cmsis/dsp/TransformFunctions
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group cpu/arm/stm32f407/cmsis/dsp_example
    ../../../../cpu/arm/stm32f407/cmsis/DSP_Lib/Examples/arm_fft_bin_example/ARM/: arm_fft_bin_data.c arm_fft_bin_example_f32.c
  group cpu/arm/stm32f407/fwlib
    ../../../../cpu/arm/stm32f407/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group cpu/arm/stm32f407/startup
    ../../../../cpu/arm/stm32f407/startup/: startup_stm32f40xx.s system_stm32f4xx.c
  group zonesion
    ../../: contiki-conf.h contiki-main.c
  group zonesion/app
    ../../app/: acc-sensor.c alarm.c autoapps.c ble.c config.c fader.c helloworld.c led.c sleepalg.c stepcounting.c test.c user.c vibrator.c zxbee.c
  group zonesion/commom
    ../../../common/dev/: LIS3DH.c pcf8563.c
  group zonesion/dev
    ../../dev/: flamag2.c fsmc.c leds-arch.c M25Pxx.c mpu9250.c rgb.c
