# IAR project template.ewp, settings and files
configuration template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED; STM32F40_41xxx; _DLIB_FILE_DESCRIPTOR=1; USE_STDPERIPH_DRIVER; xWITH_IPV6; xWITH_II_802154; xWITH_RPL; STM32F10X_MD; HSE_VALUE=8000000; WITH_LORA; WITH_xLab; REGION_CN470
  ICCARM.CCDiagSuppress: Pa050,Pe767
  ICCARM.CCIncludePath2: ..\..\..\..\core; ..\..\..\..\core\net; ..\..\..\..\core\net\mac; ..\..\..\..\core\net\rpl; ..\..\..\..\core\net\rime; ..\..\..\..\apps; ..\..\..\..\apps\shell; ..\..\..\..\apps\serial-shell; ..\..\common\cpu; ..\..\common\cpu\stm32f10x; ..\..\common\cpu\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\common\cpu\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\common; ..\..\common\app; ..\..\common\dev; ..\src; ..\..\common\mac; ..\..\common\mac\region; ..\..\common\radio; ..\..\common\radio\sx1276; ..\..\common\crypto; ..\..\common\system
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/serial-shell
    ../../../../apps/serial-shell/: serial-shell.c
  group app/shell
    ../../../../apps/shell/: shell.c
  group core/dev
    ../../../../core/dev/: leds.c nullradio.c
  group core/lib
    ../../../../core/lib/: assert.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c strncasecmp.c trickle-timer.c
  group core/net
    ../../../../core/net/: dhcpc.c hc.c nbr-table.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c rawpacket-udp.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    ../../../../core/net/mac/: contikimac.c csma.c cxmac.c frame802154.c framer-802154.c framer-nullmac.c lpp.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c sicslowmac.c xmac.c
  group core/net/rime
    ../../../../core/net/rime/: rimeaddr.c
  group core/net/rpl
    ../../../../core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    ../../../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile-aggregates.c profile.c rtimer.c stimer.c timer.c
  group zonesion/cpu/stm32f10x
    ../../common/cpu/stm32f10x/: clock.c rtc.c sip2.c system_stm32f10x.c timer1.c uart1.c uart2.c uart3.c
  group zonesion/cpu/stm32f10x/cmsis/cm3/core
    ../../common/cpu/stm32f10x/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group zonesion/cpu/stm32f10x/cmsis/cm3/stm32f10x-start
    ../../common/cpu/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group zonesion/cpu/stm32f10x/STM32F10x_StdPeriph_Driver
    ../../common/cpu/stm32f10x/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group zonesion/LoRaWAN
    ../../common/: contiki-conf.h contiki-main.c
    ../: readme.txt
  group zonesion/LoRaWAN/app
    ../../common/app/: at-uart.c at.c lorawan.c zxbee-inf.c zxbee-sys-command.c zxbee.c
  group zonesion/LoRaWAN/dev
    ../../common/dev/: config.c debug.c leds-arch.c relay.c sx1278-io.c
  group zonesion/LoRaWAN/LoRaWAN/crypto
    ../../common/crypto/: aes.c cmac.c
  group zonesion/LoRaWAN/LoRaWAN/mac
    ../../common/mac/: LoRaMac.c LoRaMacCrypto.c
  group zonesion/LoRaWAN/LoRaWAN/radio
    ../../common/radio/sx1276/: sx1276.c
  group zonesion/LoRaWAN/LoRaWAN/region
    ../../common/mac/region/: Region.c RegionCN470.c RegionCommon.c
  group zonesion/LoRaWAN/LoRaWAN/system
    ../../common/system/: mac-timer.c sx1276-board.c utilities.c
  group zonesion/LoRaWAN/sensor
    ../src/: autoapps.c sensor.c
